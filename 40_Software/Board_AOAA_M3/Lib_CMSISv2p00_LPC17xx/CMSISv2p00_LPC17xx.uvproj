# Keil uVision project CMSISv2p00_LPC17xx.uvproj, settings and files
target CMSISv2p00_LPC17xx (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: CMSISv2p00_LPC17xx (library)
  c flags: Optim=1
  c misc: --gnu
  c include: .\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group inc
    ./inc/: core_cm3.h core_cmFunc.h core_cmInstr.h LPC17xx.h system_LPC17xx.h
  group src
    ./src/: core_cm3.c system_LPC17xx.c
